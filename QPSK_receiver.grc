options:
  parameters:
    author: native
    generate_options: qt_gui
    id: QPSK_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.35'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 910e6
    step: 100e6
    stop: 5.8e9
    value: 910e6
  states: {state: disabled}
- name: fc
  id: variable
  parameters:
    value: fc_select
  states: {}
- name: fc_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,2,1
    label0: 910 MHz
    label1: 1.8 GHz
    label2: 5.8 GHz
    num_opts: '3'
    option0: 910e6
    option1: 1.8e9
    option2: 5.8e9
    type: real
    value: 910e6
    widget: radio_buttons
  states: {}
- name: gain_rx1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    start: '20'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: gain_rx2
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    start: '20'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: mult1
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    start: '1'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: mult2
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    start: '1'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: int(symb_rate*11/param)
  states: {}
- name: param
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: '15'
  states: {}
- name: rrc_rx1
  id: variable
  parameters:
    value: firdes.root_raised_cosine(gain_rx1,samp_rate,symb_rate,alpha,num_taps)
  states: {}
- name: rrc_rx2
  id: variable
  parameters:
    value: firdes.root_raised_cosine(gain_rx2,samp_rate,symb_rate,alpha,num_taps)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    start: '0'
    step: '0.02'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symb_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: 32*param
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mult1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mult2
    type: complex
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: preamble_len
    sps: sps
    symbols: preamble
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_corr_est_cc_0_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: preamble_len
    sps: sps
    symbols: preamble
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: loop_bw
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: sps/2
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_rx1
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: sps/2
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_rx2
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2*symb_rate*(1+alpha)
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: symb_rate
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2*symb_rate*(1+alpha)
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: symb_rate*2
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,2,2
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    gui_hint: 2,2,2,2
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    gui_hint: 4,2,2,2
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,0,2,2
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: fc
    center_freq1: fc
    dev_addr: '"addr=10.10.23.6"'
    gain0: rx_gain
    gain1: rx_gain
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rx2
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_const_sink_x_0_0, '1']
- [digital_corr_est_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_corr_est_cc_0_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', virtual_sink_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', virtual_sink_1, '0']
- [low_pass_filter_0, '0', digital_corr_est_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0_0, '0', digital_corr_est_cc_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0, '1']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', low_pass_filter_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0, '1']
- [virtual_source_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0_0, '0', digital_costas_loop_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
