options:
  parameters:
    author: native
    generate_options: qt_gui
    id: QPSK_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.35'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 910e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '20'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j,-1-1j'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: '10'
  states: {}
- name: qpsk
  id: variable
  parameters:
    value: '[-1-1j,-1+1j,1+1j,1-1j]'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.02'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: RX1
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: RX2
    type: complex
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '15'
    sps: '32'
    symbols: preamble
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_corr_est_cc_0_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '15'
    sps: '32'
    symbols: preamble
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*math.pi/100
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*math.pi/100
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi/100
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '32'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi/100
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '32'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.1'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '30'
    ntaps: '352'
    samp_rate: samp_rate
    sym_rate: 32e3
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '20'
    ntaps: '352'
    samp_rate: samp_rate
    sym_rate: 32e3
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: fc
    center_freq1: fc
    gain0: rx_gain
    gain1: rx_gain
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rx2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rx2
  states: {}

connections:
- [digital_corr_est_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_corr_est_cc_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_file_sink_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_2, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_file_sink_1, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0, '1']
- [digital_costas_loop_cc_0_0, '0', qtgui_time_sink_x_2, '1']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [root_raised_cosine_filter_0_0, '0', virtual_sink_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', root_raised_cosine_filter_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '1', root_raised_cosine_filter_0_0, '0']
- [virtual_source_0, '0', digital_corr_est_cc_0, '0']
- [virtual_source_0_0, '0', digital_corr_est_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
